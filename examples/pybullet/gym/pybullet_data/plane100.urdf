Commit message: close. physx doesn't work, pbyullet does

File: examples/pybullet/gym/pybullet_data/plane100.urdf (robot description, URDF)
Before this commit: robot floor, 1 links, 0 joints
Links:
- link floor: geometry collision box size=200 200 0.001; visual box size=200 200 0.001
